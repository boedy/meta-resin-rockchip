SUPERVISOR_REPOSITORY_marsboard-rk3066 = "resin/armv7hf-supervisor"
LED_FILE_marsboard-rk3066 = "/sys/class/leds/beaglebone\:green\:usr3/brightness"
