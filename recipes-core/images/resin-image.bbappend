include resin-image-flasher.inc

#IMAGE_INSTALL_append_marsboard-rk3066 = " bb-org-overlays"
IMAGE_INSTALL_append_rockchip = " bb-org-overlays"
